# Keil uVision project Blinky.uvprojx, settings and files
target Simulator (6210000::V6.21::ARMCLANG)
  device: SSE-310-MPS3_FVP ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.4.0
  cpu: IRAM(0x31000000,0x00020000) IRAM2(0x00000000,0x00008000) IROM(0x11000000,0x00200000) XRAM(0x01000000,0x00200000) XRAM2(0x20000000,0x00002000) XRAM3(0x20002000,0x00002000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x200000
  memory RVCT6: ROM 0x1000000 size 0x200000
  memory RVCT7: ROM 0x20000000 size 0x2000
  memory RVCT8: ROM 0x20002000 size 0x2000
  memory RVCT9: RAM 0x31000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x8000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Device:Startup 2.0.0
